Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
Time: 2020-04-23T18:09:33
Written by: IfcOpenShell 0.6.0b0
Made in: IfcOpenShell 0.6.0b0

# IfcProjectLibrary, OmniClass
Classification: OmniClass
